<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UAZ_Fuel_level_indicator.ewp</path>
  </project>
  <batchBuild />
</workspace>
